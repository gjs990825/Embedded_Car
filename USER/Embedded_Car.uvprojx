# Keil uVision project Embedded_Car.uvprojx, settings and files
target Embedded_Car (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Embedded_Car
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c misc: --no_multibyte_chars
  c include: ..\CMSIS;..\FWLIB\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\timer;..\my_lib;..\MALLOC;..\HARDWARE;..\HARDWARE\Task_Board;..\HARDWARE\Core_Board;..\HARDWARE\CAN;..\HARDWARE\Movement;..\HARDWARE\Task_Board\BH1705;..\HARDWARE\Task_Board\INFARED;..\HARDWARE\Task_Board\SYN7318;..\HARDWARE\Task_Board\ULTRASONIC;..\HARDWARE\Core_Board\POWER_CHECK;..\HARDWARE\Core_Board\UART;..\HARDWARE\Core_Board\UART\UART_A72;..\APP\Movement;..\APP\Movement\A_Star;..\APP\Movement\PID;..\APP\Movement\ROAD_CHECK;..\APP\Debug;..\APP\Task;..\APP\CAN_TIMER;..\APP\Protocol;..\APP\Movement\Route;..\APP\AGV;..\HARDWARE\Core_Board\RC522;..\APP\Data_Interaction
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
  group APP
    ../APP/Debug/: debug.c
    ../APP/Movement/Route/: route.c
    ../APP/Protocol/: protocol.c
    ../APP/Task/: task.c independent_task.c
    ../APP/Movement/: movement.c
    ../APP/CAN_TIMER/: can_timer.c
    ../APP/Movement/A_Star/: a_star.c
    ../APP/Movement/PID/: pid.c
    ../APP/Movement/ROAD_CHECK/: roadway_check.c
    ../APP/AGV/: agv.c
    ../APP/Data_Interaction/: data_interaction.c
  group HARDWARE
    ../HARDWARE/: hardware.c
    ../HARDWARE/Task_Board/: tba.c
    ../HARDWARE/Core_Board/: cba.c
    ../HARDWARE/Core_Board/POWER_CHECK/: power_check.c
    ../HARDWARE/Core_Board/UART/: uart_drv.c
    ../HARDWARE/Core_Board/UART/UART_A72/: uart_a72.c
    ../HARDWARE/Task_Board/BH1705/: bh1750.c
    ../HARDWARE/Task_Board/INFARED/: infrared.c
    ../HARDWARE/Task_Board/ULTRASONIC/: ultrasonic.c
    ../HARDWARE/Task_Board/SYN7318/: voice.c
    ../HARDWARE/Core_Board/RC522/: RC522.C
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/timer/: Timer.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group my_lib
    ../my_lib/: my_lib.c data_base.c data_filtering.c
  group CAN
    ../HARDWARE/CAN/: can_drv.c CanP_HostCom.c fifo_drv.c Hard_Can.c can_user.c Can_check.c
  group MALLOC
    ../MALLOC/: malloc.c
  group Doc
    ../: README.md
